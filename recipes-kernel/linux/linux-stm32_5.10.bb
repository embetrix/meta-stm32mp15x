require linux-stm32.inc

LINUX_VERSION = "5.10.61"
SRCBRANCH = "v5.10-stm32mp"
SRCREV = "1c7048a18d084dbc142244dd4082e6109ec87a71"

LIC_FILES_CHKSUM = "file://${S}/COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"
